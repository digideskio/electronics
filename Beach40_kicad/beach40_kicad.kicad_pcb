# Repository digideskio/electronics

File README.md:

Beach40_kicad
=============
Teaching myself KiCad, schematic generation, footprints and PCB layout by designing a board for Peter Parker's Beach40 transceiver. More info on the design at http://vk3ye.com/

To get this up and running, you'll need to do a
```
git submodule init
git submodule update
```
to pull in the relevant FreeTronics KiCad libraries.

VOX
===

Simple Voice Activated Switch circuit

My_LBS
======

My version of Pete Juliano's (N6QW) "Let's Build Something" SSB transceiver.  Design details at http://jessystems.com/LBS_Detail.html

The only differnce so far is the audio output stages. I had an LM386 on hand, and used that instead, with a 2n3904 audio pre-amp.

License
=======

All files and designs in this repository are licensed as CC-BY-SA. See LICENSE for details, here's a summary:

You are free to:
* Share — copy and redistribute the material in any medium or format
* Adapt — remix, transform, and build upon the material

for any purpose, even commercially.

Under the following terms:
* Attribution — You must give appropriate credit, provide a link to the license, and indicate if changes were made. You may do so in any reasonable manner, but not in any way that suggests the licensor endorses you or your use.
* ShareAlike — If you remix, transform, or build upon the material, you must distribute your contributions under the same license as the original.
* No additional restrictions — You may not apply legal terms or technological measures that legally restrict others from doing anything the license permits.

The licensor cannot revoke these freedoms as long as you follow the license terms.

## KiCad design Beach40_kicad/beach40_kicad.kicad_pcb

Parts:
C1, C2, C14, C16, C17, C20, C21, C23, C25, C29, C30, C32: 100n; 1210_CAP
C3: 10n; 1210_CAP
C4, C15, C31: 1n; 1210_CAP
C5: 1u; CAP_ELECTRO_D4S1.8
C6: 68p; CAP_ELECTRO_D4S1.8
C7: 4.7u; CAP_ELECTRO_D4S1.8
C8: 10nF; 1210_CAP
C9, C10, C12, C26: 220u; CAP_ELECTRO_D4S1.8
C11: 47u; CAP_ELECTRO_D4S1.8
C13: 4.7n; 1210_CAP
C18, C19, C27, C28: 220p; 1210_CAP
C22, C24: 820p; 1210_CAP
C33: 18p; 1210_CAP
CAP_TRIM1: 4-40p; C2
D1, D2, D3, D4: DIODE; 1206_DIODE
K1: RELAY_2RT; Relay_DPDT_Custom
L1, L2: Bifilar_10t_choke; Biflar_10t_choke
L3, L6, L7, L8: 1u; 1206
L9: 3T FB; IND_SRP1040
P1: LO In; BNC_Socket_TYCO-AMP_LargePads
P2: MIC_IN; Pin_Header_Straight_1x02
P3: Audio Out; Pin_Header_Straight_1x02
P4: ANT; BNC_Socket_TYCO-AMP_LargePads
PTT1: SW_PUSH; Pin_Header_Straight_1x02
Q1, Q5: BC548; TO-92_Inline_Narrow_Oval
Q2: 2N2222; SOT23_TRANSISTOR
Q3, Q4: BD139; TO220_VERT
R1: 22k; 1210
R2, R19: 330; 1210
R3, R8, R10, R15: 2.2k; 1210
R4, R9, R12: 100; 1210
R5: 220; 1210
R6, R13: 10; 1210
R7: 18; 1210
R11: 1k1; 1210
R14: 470; 1210
R16: 22; 1210
R17: 4.7; 1210
R18: 6.8k; 1210
R20: 2.2; 1210
R21: 100k; 1210
R22: 4.7k; 1210
T1: 4:10_Transformer; 4_10_Transformer
U1: LM386; SOIC-8-1EP_3.9x4.9mm_Pitch1.27mm
VR1: 200; POT_TRIM_PTH

Connections:
+12V: K1.5 (C1), PTT1.1
Audio: C5.2 (-), C7.2 (-), C8.1, D1.K, D2.A
GND: C1.1, C4.2, C6.2 (-), C8.2, C9.2 (-), C10.2 (-), C14.2, C17.2, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C26.2 (-), C27.2, C28.2, C30.2, C32.2, CAP_TRIM1.1, D3.A, D4.K, L7.1, P1.2 (Ext), P2.2, P3.2, P4.2 (Ext), Q4.1 (E), Q5.3 (E), R5.2, R7.2, R11.2, R12.2, R14.2, R16.2, R19.2, T1.4, U1.2 (-), U1.4 (Gnd)
LPF: C18.1, C19.1, K1.12 (C2), L3.1
unnamed: C1.2, R1.1, R2.2, R3.2
unnamed: C2.1, C4.1, Q1.2 (B), R4.2
unnamed: C2.2, P2.1, R1.2
unnamed: C3.1, VR1.W
unnamed: C3.2, P1.1 (In)
unnamed: C5.1 (+), Q1.1 (C), R3.1, R4.1
unnamed: C6.1 (+), Q1.3 (E), R5.1
unnamed: C7.1 (+), U1.3 (+)
unnamed: C10.1 (+), R6.2, U1.6 (Pwr)
unnamed: C11.1 (+), R8.2, U1.1 (Gain)
unnamed: C11.2 (-), R7.1
unnamed: C12.1 (+), C13.1, R20.1, U1.5
unnamed: C12.2 (-), P3.1
unnamed: C13.2, R8.1
unnamed: C14.1, L1.3 (v_in), R9.2
unnamed: C15.1, C33.1
unnamed: C15.2, C16.2, T1.3
unnamed: C16.1, Q2.B, R10.2, R11.1
unnamed: C17.1, R13.2
unnamed: C20.1, L1.2 (rf_out)
unnamed: C20.2, Q3.3 (B), R14.1, R15.2
unnamed: C22.1, L3.2, L6.1
unnamed: C23.1, R17.2
unnamed: C24.1, L6.2, L8.1
unnamed: C25.1, Q4.3 (B), R18.2, R19.1
unnamed: C25.2, L2.2 (rf_out)
unnamed: C27.1, C28.1, L8.2, P4.1 (In)
unnamed: C29.2, L9.1, Q4.2 (C), R18.1
unnamed: C30.1, R20.2
unnamed: C31.1, Q5.2 (B), R21.2
unnamed: C33.2, Q5.1 (C), R21.1, R22.2
unnamed: CAP_TRIM1.2, D1.A, D3.K, T1.1, VR1.2
unnamed: D2.K, D4.A, T1.2, VR1.1
unnamed: K1.8, PTT1.2
unnamed: K1.9, L7.2
unnamed: L1.1 (rf_in), Q2.C, R10.1
unnamed: L2.1 (rf_in), Q3.2 (C), R15.1
unnamed: Q2.E, R12.1, R13.1
unnamed: Q3.1 (E), R16.1, R17.1
T/R-P-NC: C9.1 (+), C32.1, K1.3 (R1), R6.1, R22.1
T/R-P-NO: C21.1, C26.1 (+), K1.1 (T1), L2.3 (v_in), L9.2, R2.1, R9.1
T/R-S-NC: C31.2, K1.14 (R2)
T/R-S-NO: C29.1, K1.16 (T2)

Board: 2 copper layers, 200.0 x 100.0 mm, 81 parts (6 on the bottom side), 47 nets.

## Commit log

2015-01-27 starting!
2015-01-27 Some tinkering.
2015-01-31 2 RF amp stages, first attempt at layout, 1206 for the most part.
2015-02-03 - more work! transmit RF path finish.
2015-02-03 All components on schematic, working out libraries.
2015-02-03 - slight fixes, working on 2 computers now!
2015-02-04 VOX added, updated README, Beach40 tweaks.
2015-02-04 update to VOX
2015-02-04 values for pot
2015-02-27 Updated schematic to include shunt RC on LM386, Minor changes for ERC, still not quite right, damn gnds and +12v don't want to join the nets.
2015-03-06 - updates for RX pre-amp
2015-03-06 more tweaks to schematic, another attempt at layout starting, missing footprints though
2015-03-07 custom chokes added for the 10 turn bifilar chokes. still some issues, libraries are a bit skeewiff
2015-03-07 first proper go of the board layout, still missing footrprints, and some nets!
2015-03-08 reverted a bit, back to SMD components, much more better! Actual start of layout now.
2015-03-09 PCB Layout getting there, struggling with Vias.
2015-03-09 - a mistake or two in the schematic! - just noticed the relay is not correct, pin mappings wierd, custom part time! - more layout
2015-03-10 random update, don't remember, think it was mucking about with vias
2015-03-10 new relay footprint that matches the schematic some more layout, RF path not good though.
2015-03-23 README update
2015-03-23 ergh, markdown!
2015-03-23 readme - license
2015-03-23 git submodule instructions unclear!
2015-03-26 my LBS with mods.
2015-03-26 moar typing!
2015-03-26 Moved custom libraries to common dir. Fixed references in the projects. A bit more work on the beach40 layout, all my mods so far for my_LBS
2015-03-28 updates updates updates!
2015-03-28 Corrected 10t bifilar choke. updates to LBS making it as built, and to re-fit the 10t choke.
2015-03-30 added PDF of schematic couple of mislaid wires!
2015-03-31 couple more tracks!
2015-03-31 fixed conflicts for Beach40
2015-04-01 more mucking about!
2015-04-02 mucking about more with layout, a bit thinner!
